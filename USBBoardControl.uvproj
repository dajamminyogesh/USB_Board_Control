# Keil uVision project USBBoardControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: USBBoardControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\myinc;C:\Users\User\Downloads\MinGW\lib\gcc\x86_64-w64-mingw32\11.2.0\include
  group Source Group 1
    ./: STARTUP.A51
  group mycode
    ./mycode/: Buzzer.c delay.c GPIO.c Led.c main.c Task.c timer.c
